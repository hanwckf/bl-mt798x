## atf-20250711/Config.in
```kconfig
#
# Copyright (c) 2023, MediaTek Inc. All rights reserved.
#
# SPDX-License-Identifier: BSD-3-Clause
#

source "plat/mediatek/apsoc_common/Config.in"
```
